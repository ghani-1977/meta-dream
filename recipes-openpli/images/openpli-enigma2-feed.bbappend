OPTIONAL_PACKAGES_remove_dm800 = " \
	wscan \
	"

OPTIONAL_PACKAGES_append_smallflash = " \
	upx \
	"

OPTIONAL_PACKAGES_remove = " \
	dvb-apps \
"
