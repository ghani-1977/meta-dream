IMAGE_INSTALL_remove = " \
	ofgwrite \
	"

IMAGE_INSTALL_remove_dm500hd = " \
	dropbear \
	enigma2-plugin-extensions-audiosync \
	enigma2-plugin-extensions-cutlisteditor \
	enigma2-plugin-extensions-moviecut \
	enigma2-plugin-extensions-ppanel \
	nfs-utils-client \
	python-pysmb \
	samba-base \
	"

IMAGE_INSTALL_remove_dm800 = " \
	dropbear \
	enigma2-plugin-extensions-audiosync \
	enigma2-plugin-extensions-cutlisteditor \
	enigma2-plugin-extensions-moviecut \
	enigma2-plugin-extensions-ppanel \
	nfs-utils-client \
	python-pysmb \
	samba-base \
	"

IMAGE_INSTALL_remove_dm800se = " \
	dropbear \
	enigma2-plugin-extensions-audiosync \
	enigma2-plugin-extensions-cutlisteditor \
	enigma2-plugin-extensions-moviecut \
	enigma2-plugin-extensions-ppanel \
	nfs-utils-client \
	python-pysmb \
	samba-base \
	"
