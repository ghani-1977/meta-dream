DEPENDS += "glib-2.0 glib-2.0-native"
