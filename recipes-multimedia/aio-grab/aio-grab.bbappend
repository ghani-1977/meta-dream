SRC_URI = "${GITHUB_URI}/oe-alliance/${BPN}.git"
