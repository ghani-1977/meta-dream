FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_dm800 = " file://legacy_kernel.patch"
